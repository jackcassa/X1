# Keil uVision project Nucleo_rtos_basic_v2.uvprojx, settings and files
target Nucleo_rtos_basic_L1 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: CPUTYPE("Cortex-M3")
  output: Nucleo_rtos_basic_v2
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: DEVICE_RTC=1 DEVICE_SLEEP=1 __ASSERT_MSG TARGET_RELEASE TARGET_STM32L152RE TARGET_NUCLEO_L152RE DEVICE_PORTINOUT=1 __CORTEX_M3 DEVICE_PWMOUT=1 MBED_BUILD_TIMESTAMP=1577642782.03 TARGET_FF_ARDUINO DEVICE_SPISLAVE=1 DEVICE_PORTOUT=1 DEVICE_FLASH=1 DEVICE_STDIO_MESSAGES=1 DEVICE_ANALOGOUT=1 TARGET_LIKE_MBED ARM_MATH_CM3 DEVICE_INTERRUPTIN=1 TARGET_LIKE_CORTEX_M3 DEVICE_ANALOGIN=1 DEVICE_PORTIN=1 TARGET_CORTEX_M DEVICE_SERIAL_FC=1 MULADDC_CANNOT_USE_R7 TARGET_FF_MORPHO DEVICE_I2C=1 TARGET_NAME=NUCLEO_L152RE DEVICE_LOWPOWERTIMER=1 TARGET_STM TOOLCHAIN_ARM TOOLCHAIN_ARM_STD DEVICE_I2C_ASYNCH=1 DEVICE_SERIAL_ASYNCH=1 TARGET_FAMILY_STM32 DEVICE_SPI=1 __MBED__=1 TARGET_STM32L1 __MBED_CMSIS_RTOS_CM MBED_TRAP_ERRORS_ENABLED=1 DEVICE_SERIAL=1 TARGET_M3 TARGET_CORTEX DEVICE_I2CSLAVE=1 __CMSIS_RTOS DEVICE_SPI_ASYNCH=1 TRANSACTION_QUEUE_SIZE_SPI=2 TOOLCHAIN_ARMC6
  c misc: -fshort-wchar -fdata-sections -Wno-deprecated-register -Wno-armcc-pragma-anon-unions -fno-exceptions -c -fshort-enums -mthumb --target=arm-arm-none-eabi -Wno-armcc-pragma-push-pop -Wno-reserved-user-defined-literal -fno-rtti -mcpu=cortex-m3 -include mbed_config.h
  c include: ;/usr/src/mbed-sdk;X_NUCLEO_IHM01A1;X_NUCLEO_IHM01A1/Components;X_NUCLEO_IHM01A1/Components/Common;X_NUCLEO_IHM01A1/Components/L6474;X_NUCLEO_IHM01A1/ST_INTERFACES;X_NUCLEO_IHM01A1/ST_INTERFACES/Actuators;X_NUCLEO_IHM01A1/ST_INTERFACES/Common;X_NUCLEO_IHM01A1/ST_INTERFACES/Communications;X_NUCLEO_IHM01A1/ST_INTERFACES/Sensors;X_NUCLEO_IHM01A1/X_NUCLEO_COMMON;X_NUCLEO_IHM01A1/X_NUCLEO_COMMON/DbgMCU;X_NUCLEO_IHM01A1/X_NUCLEO_COMMON/DevI2C;X_NUCLEO_IHM01A1/X_NUCLEO_COMMON/DevSPI;mbed-os;mbed-os/cmsis/TARGET_CORTEX_M;mbed-os/drivers;mbed-os/events;mbed-os/events/equeue;mbed-os/features;mbed-os/features/filesystem;mbed-os/features/filesystem/bd;mbed-os/features/filesystem/fat;mbed-os/features/filesystem/fat/ChaN;mbed-os/features/frameworks;mbed-os/features/frameworks/greentea-client;mbed-os/features/frameworks/greentea-client/greentea-client;mbed-os/features/frameworks/unity;mbed-os/features/frameworks/unity/unity;mbed-os/features/frameworks/utest;mbed-os/features/frameworks/utest/utest;mbed-os/features/mbedtls;mbed-os/features/mbedtls/inc;mbed-os/features/mbedtls/inc/mbedtls;mbed-os/features/mbedtls/platform;mbed-os/features/mbedtls/platform/inc;mbed-os/features/mbedtls/targets/TARGET_STM;mbed-os/features/netsocket;mbed-os/features/netsocket/cellular;mbed-os/features/netsocket/cellular/generic_modem_driver;mbed-os/features/netsocket/cellular/utils;mbed-os/hal;mbed-os/hal/storage_abstraction;mbed-os/platform;mbed-os/rtos;mbed-os/rtos/TARGET_CORTEX;mbed-os/rtos/TARGET_CORTEX/rtx4;mbed-os/rtos/TARGET_CORTEX/rtx5;mbed-os/rtos/TARGET_CORTEX/rtx5/Include;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source;mbed-os/targets/TARGET_STM;mbed-os/targets/TARGET_STM/TARGET_STM32L1;mbed-os/targets/TARGET_STM/TARGET_STM32L1/TARGET_NUCLEO_L152RE;mbed-os/targets/TARGET_STM/TARGET_STM32L1/TARGET_NUCLEO_L152RE/device;mbed-os/targets/TARGET_STM/TARGET_STM32L1/device
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed-os/targets/TARGET_STM/TARGET_STM32L1/TARGET_NUCLEO_L152RE/device/TOOLCHAIN_ARM_STD/stm32l152re.sct
  link misc: --show_full_path --cpu=Cortex-M3 --any_contingency --keep=os_cb_sections --legacyalign
  group mbed-os
    mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config-no-entropy.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
    mbed-os/features/mbedtls/targets/TARGET_STM/: aes_alt.c aes_alt.h md5_alt.c md5_alt.h sha1_alt.c sha1_alt.h sha256_alt.c sha256_alt.h
    mbed-os/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.cpp Ethernet.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h UARTSerial.cpp UARTSerial.h
    mbed-os/targets/TARGET_STM/: analogin_api.c analogout_api.c can_api.c gpio_api.c gpio_irq_api.c gpio_object.h hal_tick_16b.c hal_tick_32b.c i2c_api.c lp_ticker.c mbed_overrides.c mbed_rtx.h nvic_addr.h PeripheralPins.h pinmap.c PinNamesTypes.h port_api.c PortNames.h pwmout_api.c rtc_api.c rtc_api_hal.h serial_api.c serial_api_hal.h sleep.c stm32_assert.h stm_spi_api.c trng_api.c us_ticker_16b.c us_ticker_32b.c
    mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h emac_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed_flash_api.c mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_sleep_manager.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed-os/targets/TARGET_STM/TARGET_STM32L1/: analogin_device.c analogout_device.c common_objects.h device.h flash_api.c gpio_irq_device.c gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.c pwmout_device.h serial_device.c spi_api.c spi_device.h
    mbed-os/features/netsocket/cellular/utils/: APN_db.h
    mbed-os/cmsis/TARGET_CORTEX_M/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    mbed-os/platform/: ATCmdParser.cpp ATCmdParser.h Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.cpp FileBase.h FileHandle.cpp FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemHandle.cpp FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.cpp LocalFileSystem.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_interface.c mbed_interface.h mbed_mem_trace.c mbed_mem_trace.h mbed_mktime.c mbed_mktime.h mbed_poll.cpp mbed_poll.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_sdk_boot.c mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.cpp Stream.h toolchain.h Transaction.h wait_api.h
    mbed-os/features/filesystem/bd/: BlockDevice.h ChainingBlockDevice.cpp ChainingBlockDevice.h HeapBlockDevice.cpp HeapBlockDevice.h MBRBlockDevice.cpp MBRBlockDevice.h ProfilingBlockDevice.cpp ProfilingBlockDevice.h SlicingBlockDevice.cpp SlicingBlockDevice.h
    mbed-os/features/filesystem/fat/ChaN/: ccsbcs.cpp diskio.h ff.cpp ff.h ffconf.h integer.h
    mbed-os/features/netsocket/: CellularBase.h CellularInterface.h emac_stack_mem.h EthInterface.h MeshInterface.h NetworkInterface.cpp NetworkInterface.h NetworkStack.cpp NetworkStack.h nsapi.h nsapi_dns.cpp nsapi_dns.h nsapi_ppp.h nsapi_types.h Socket.cpp Socket.h SocketAddress.cpp SocketAddress.h TCPServer.cpp TCPServer.h TCPSocket.cpp TCPSocket.h UDPSocket.cpp UDPSocket.h WiFiAccessPoint.cpp WiFiAccessPoint.h WiFiInterface.h
    mbed-os/targets/TARGET_STM/TARGET_STM32L1/TARGET_NUCLEO_L152RE/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32l152xe.h stm32l1xx.h system_clock.c system_stm32l1xx.h
    mbed-os/rtos/TARGET_CORTEX/rtx4/: cmsis_os.h cmsis_os1.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/Include/: cmsis_os2.h os_tick.h
    mbed-os/rtos/: ConditionVariable.cpp ConditionVariable.h EventFlags.cpp EventFlags.h Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
    mbed-os/features/filesystem/: Dir.cpp Dir.h File.cpp File.h FileSystem.cpp FileSystem.h mbed_filesystem.h
    mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-os/events/equeue/: equeue.c equeue.h equeue_mbed.cpp equeue_platform.h equeue_posix.c
    mbed-os/events/: Event.h EventQueue.cpp EventQueue.h mbed_events.h mbed_shared_queues.cpp mbed_shared_queues.h
    mbed-os/features/filesystem/fat/: FATFileSystem.cpp FATFileSystem.h
    mbed-os/features/frameworks/greentea-client/source/: greentea_metrics.cpp greentea_serial.cpp greentea_test_env.cpp
    mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_metrics.h greentea_serial.h test_env.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM/TARGET_M3/: irq_cm3.S
    mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    mbed-os/: mbed.h
    mbed-os/rtos/TARGET_CORTEX/: mbed_boot.c mbed_rtos1_types.h mbed_rtos_storage.h mbed_rtx_conf.h mbed_rtx_handlers.c mbed_rtx_idle.cpp
    mbed-os/features/mbedtls/platform/src/: mbed_trng.c
    mbed-os/targets/TARGET_STM/TARGET_STM32L1/TARGET_NUCLEO_L152RE/: objects.h PeripheralNames.h PeripheralPins.c PinNames.h
    mbed-os/features/netsocket/cellular/: onboard_modem_api.h
    mbed-os/features/netsocket/cellular/generic_modem_driver/: OnboardCellularInterface.cpp OnboardCellularInterface.h PPPCellularInterface.cpp PPPCellularInterface.h UARTCellularInterface.cpp UARTCellularInterface.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/Source/: os_systick.c os_tick_ptim.c
    mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/: rt_OsEventObserver.c rt_OsEventObserver.h rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_lib.h rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config/: RTX_Config.c RTX_Config.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include/: rtx_evr.h rtx_os.h
    mbed-os/targets/TARGET_STM/TARGET_STM32L1/TARGET_NUCLEO_L152RE/device/TOOLCHAIN_ARM_STD/: startup_stm32l152xe.S
    mbed-os/targets/TARGET_STM/TARGET_STM32L1/device/: stm32_hal_legacy.h stm32l1xx_hal.c stm32l1xx_hal.h stm32l1xx_hal_adc.c stm32l1xx_hal_adc.h stm32l1xx_hal_adc_ex.c stm32l1xx_hal_adc_ex.h stm32l1xx_hal_comp.c stm32l1xx_hal_comp.h stm32l1xx_hal_comp_ex.h stm32l1xx_hal_conf.h stm32l1xx_hal_cortex.c stm32l1xx_hal_cortex.h stm32l1xx_hal_crc.c stm32l1xx_hal_crc.h stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp.h stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_cryp_ex.h stm32l1xx_hal_dac.c stm32l1xx_hal_dac.h stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dac_ex.h stm32l1xx_hal_def.h stm32l1xx_hal_dma.c stm32l1xx_hal_dma.h stm32l1xx_hal_flash.c stm32l1xx_hal_flash.h stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ex.h stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_flash_ramfunc.h stm32l1xx_hal_gpio.c stm32l1xx_hal_gpio.h stm32l1xx_hal_gpio_ex.h stm32l1xx_hal_i2c.c stm32l1xx_hal_i2c.h stm32l1xx_hal_i2s.c stm32l1xx_hal_i2s.h stm32l1xx_hal_irda.c stm32l1xx_hal_irda.h stm32l1xx_hal_iwdg.c stm32l1xx_hal_iwdg.h stm32l1xx_hal_lcd.c stm32l1xx_hal_lcd.h stm32l1xx_hal_nor.c stm32l1xx_hal_nor.h stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp.h stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_opamp_ex.h stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd.h stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pcd_ex.h stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr.h stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_pwr_ex.h stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc.h stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rcc_ex.h stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc.h stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_rtc_ex.h stm32l1xx_hal_sd.c stm32l1xx_hal_sd.h stm32l1xx_hal_smartcard.c stm32l1xx_hal_smartcard.h stm32l1xx_hal_spi.c stm32l1xx_hal_spi.h stm32l1xx_hal_spi_ex.c stm32l1xx_hal_spi_ex.h stm32l1xx_hal_sram.c stm32l1xx_hal_sram.h stm32l1xx_hal_tim.c stm32l1xx_hal_tim.h stm32l1xx_hal_tim_ex.c stm32l1xx_hal_tim_ex.h stm32l1xx_hal_uart.c stm32l1xx_hal_uart.h stm32l1xx_hal_usart.c stm32l1xx_hal_usart.h stm32l1xx_hal_wwdg.c stm32l1xx_hal_wwdg.h stm32l1xx_ll_adc.c stm32l1xx_ll_adc.h stm32l1xx_ll_bus.h stm32l1xx_ll_comp.c stm32l1xx_ll_comp.h stm32l1xx_ll_cortex.h stm32l1xx_ll_crc.c stm32l1xx_ll_crc.h stm32l1xx_ll_dac.c stm32l1xx_ll_dac.h stm32l1xx_ll_dma.c stm32l1xx_ll_dma.h stm32l1xx_ll_exti.c stm32l1xx_ll_exti.h stm32l1xx_ll_fsmc.c stm32l1xx_ll_fsmc.h stm32l1xx_ll_gpio.c stm32l1xx_ll_gpio.h stm32l1xx_ll_i2c.c stm32l1xx_ll_i2c.h stm32l1xx_ll_iwdg.h stm32l1xx_ll_opamp.c stm32l1xx_ll_opamp.h stm32l1xx_ll_pwr.c stm32l1xx_ll_pwr.h stm32l1xx_ll_rcc.c stm32l1xx_ll_rcc.h stm32l1xx_ll_rtc.c stm32l1xx_ll_rtc.h stm32l1xx_ll_sdmmc.c stm32l1xx_ll_sdmmc.h stm32l1xx_ll_spi.c stm32l1xx_ll_spi.h stm32l1xx_ll_system.h stm32l1xx_ll_tim.c stm32l1xx_ll_tim.h stm32l1xx_ll_usart.c stm32l1xx_ll_usart.h stm32l1xx_ll_utils.c stm32l1xx_ll_utils.h stm32l1xx_ll_wwdg.h system_stm32l1xx.c
    mbed-os/features/frameworks/unity/source/: unity.c
    mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
    mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_stack_trace.cpp utest_types.cpp
    mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
  group Nucleo_rtos_basic_v2
    ./: main.cpp mbed_config.h Tokenizer.cpp Tokenizer.h
  group X_NUCLEO_IHM01A1
    X_NUCLEO_IHM01A1/ST_INTERFACES/Actuators/: BDCMotor.h StepperMotor.h
    X_NUCLEO_IHM01A1/ST_INTERFACES/Common/: Component.h
    X_NUCLEO_IHM01A1/Components/Common/: component_def.h motor_def.h
    X_NUCLEO_IHM01A1/X_NUCLEO_COMMON/DbgMCU/: DbgMCU.h
    X_NUCLEO_IHM01A1/X_NUCLEO_COMMON/DevI2C/: DevI2C.h
    X_NUCLEO_IHM01A1/X_NUCLEO_COMMON/DevSPI/: DevSPI.h
    X_NUCLEO_IHM01A1/ST_INTERFACES/Sensors/: GyroSensor.h HumiditySensor.h LightSensor.h MagneticSensor.h MotionSensor.h PressureSensor.h RangeSensor.h TempSensor.h
    X_NUCLEO_IHM01A1/Components/L6474/: L6474.cpp L6474.h L6474_config.h L6474_def.h
    X_NUCLEO_IHM01A1/ST_INTERFACES/Communications/: Nfc.h
